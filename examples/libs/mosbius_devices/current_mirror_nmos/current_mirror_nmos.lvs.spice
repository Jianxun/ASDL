* Netlist generated by ASDL for backend `lvs.klayout`

* ===============================================
* current_mirror_nmos
* /Users/jianxunzhu/Documents/GitHub/osic-suite/ASDL/examples/libs/mosbius_devices/current_mirror_nmos/current_mirror_nmos.asdl
* ===============================================
.subckt current_mirror_nmos iref iout vss
Mmn_ref iref iref vss vss nfet_03v3 L=0.5u W=1*6*5u
Mmn_out iout iref vss vss nfet_03v3 L=0.5u W=1*6*5u
.ends
